# Keil uVision project APM32E103MINI-Blinky.uvprojx, settings and files
target APM32E103_MINI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32E103_MINI
  c include: .\Include;.\Board;.\Board\Board_APM32E103_MINI\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Board
    ./Board/: Board.c
  group Application
    ./Source/: main.c
  group readme
    ./: readme.txt
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EINT 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:RCM 1.0.1, Device:StdPeriph Drivers:USART 1.0.1
